# Keil uVision project dgm_boot.uvprojx, settings and files
target dgm_boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dgm_boot +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\@L.bin"
  AfterMake: ..\..\tools\bin_process\bin_packer.exe -i ".\object\dgm_boot.bin" -o "..\..\tools\auto_flash\windows\A2\firmware\dgm_boot_released_A2.bin" -s 25KB -vf "..\Source\version.h"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,ARM_MATH_CM4
  c misc: --c99
  c include: ..\Source;..\Source\heatshrink;..\CMSIS;..\CMSIS\GD\GD32C10x\Include;..\GD32C10x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8016800 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Source/: main.c gd32c10x_it.c version.h
  group GD32C10x_StdPeriph_Driver
    ../GD32C10x_standard_peripheral/Source/: gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_ctc.c gd32c10x_can.c gd32c10x_dbg.c gd32c10x_fwdgt.c gd32c10x_spi.c gd32c10x_adc.c gd32c10x_bkp.c
  group CMSIS
    ../CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Startup
    ../CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s

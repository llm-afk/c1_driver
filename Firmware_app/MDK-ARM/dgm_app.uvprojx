# Keil uVision project dgm_app.uvprojx, settings and files
target dgm_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dgm_app_fw +hex
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\@L.bin"
  AfterMake: ..\..\tools\bin_process\bin_packer.exe -i ".\object\dgm_app_fw.bin" -o ".\object\dgm_app_released.bin" -s 40KB -vf "..\Source\version.h"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,ARM_MATH_CM4
  c misc: --c99
  c include: ..\Source;..\CMSIS;..\CMSIS\GD\GD32C10x\Include;..\GD32C10x_standard_peripheral\Include;..\Source\Eeprom\Core;..\Source\Eeprom\Porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xb400
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Source/: main.c gd32c10x_it.c soc.c com_can.c encoder.c motor_ctrl.c motion_planner.c od.c dfu.c torque_calib.c pid.c util.c fifo_buffer.c version.h
  group GD32C10x_StdPeriph_Driver
    ../GD32C10x_standard_peripheral/Source/: gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_ctc.c gd32c10x_can.c gd32c10x_dbg.c gd32c10x_fwdgt.c gd32c10x_spi.c gd32c10x_adc.c gd32c10x_bkp.c
  group CMSIS
    ../CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Startup
    ../CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Doc
    ../: readme.txt
  group Eeprom/Core
    ../Source/Eeprom/Core/: eeprom_emul_conf.h eeprom_emul.c
  group Eeprom/Porting
    ../Source/Eeprom/Porting/: flash_interface.c
